# Keil uVision project uCOS-III.uvprojx, settings and files
target uCOS-III (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOS-III +hex
  c flags: Optim=1 wLevel=1
  c define: STM32F2XX,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=177
  c include: ..\app;..\bsp;..\driver;..\Libraries\STM32F2xx_StdPeriph_Driver\src;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\Libraries\STM32F2x7_ETH_Driver\src;..\Libraries\STM32F2x7_ETH_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device;..\UCOSIII\uC-LIB;..\UCOSIII\uC-CPU;..\UCOSIII\uCOS-CONFIG;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\FATFS;..\lwip\include;..\lwip\apps\tcpecho_raw;..\lwip\apps;..\lwip\apps\socket_examples
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../app/: app.c os_app_hooks.c protocol.c
    ../Libraries/CMSIS/Device/: system_stm32f2xx.c
  group BSP
    ../bsp/: bsp.c bsp_int.c bsp_ioe.c bsp_lcd.c bsp_os.c bsp_ser.c
  group driver
    ../driver/: w25qxx.c usart.c gprs.c timer.c spi.c rtc.c lan8720.c eth.c
  group FATFS
    ../FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group STM32F2x7_ETH
    ../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group uCOSIII\uC-LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOSIII\uC-CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uCOSIII\uCOS-III Ports
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s
  group uCOSIII\uCOS-III Source
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group startup
    ../app/: cstartup.s
  group lwip\arch
    ../lwip/arch/: sys_arch.c
  group lwip\apps
    ../lwip/apps/: rawudp.c
  group lwip\api
    ../lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip\netif
    ../lwip/netif/: ethernet.c ethernetif.c
  group lwip\core
    ../lwip/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip\core\ipv4
    ../lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
software components: CMSIS:CORE 5.0.2
